<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>value</key><value>"192.168.0.101"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>f_GHz*1e9+f_MHz*s_MHz*1e6+f_kHz*s_kHz*1e3+f_Hz*s_Hz</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f_GHz</value></param>
<param><key>label</key><value>GHz</value></param>
<param><key>value</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>4</value></param>
<param><key>num_steps</key><value>5</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f_Hz</value></param>
<param><key>label</key><value>Hz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>999</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>s_Hz</value></param>
<param><key>label</key><value>" "</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[-1,1]</value></param>
<param><key>labels</key><value>["-","+"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f_kHz</value></param>
<param><key>label</key><value>kHz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>999</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>s_kHz</value></param>
<param><key>label</key><value>" "</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[-1,1]</value></param>
<param><key>labels</key><value>["-","+"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f_MHz</value></param>
<param><key>label</key><value>MHz</value></param>
<param><key>value</key><value>375</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>999</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>s_MHz</value></param>
<param><key>label</key><value>" "</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[-1,1]</value></param>
<param><key>labels</key><value>["-","+"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>e4406a_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>e4406a_rctrl</value></param>
<param><key>function_name</key><value>get_frequency</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>e4406a_E4406A_remote_control</key>
<param><key>id</key><value>e4406a_rctrl</value></param>
<param><key>ip_addr</key><value>ip_addr</value></param>
<param><key>frequency</key><value>freq</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>Freq (MHz)</value></param>
<param><key>value</key><value>e4406a_freq/1e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>lambda x: "%.6f" % x</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>E4406A control</value></param>
<param><key>author</key><value>F4EXB</value></param>
<param><key>description</key><value>Agilent E4406A remote control</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>e4406a_rctrl</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
