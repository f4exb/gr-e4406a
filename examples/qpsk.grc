<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_factor</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate_multiplier</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>e4406a_E4406A_source</key>
<param><key>id</key><value>E4406A_source_0</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
<param><key>intfrequency</key><value>freq</value></param>
<param><key>resbw</key><value>resbw</value></param>
<param><key>nb_points</key><value>samp_rate*block_factor</value></param>
<param><key>rfgain</key><value>rfgain</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Freq (Hz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>2.375e9</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>28.5</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>resbw</value></param>
<param><key>label</key><value>Res BW (Hz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>samp_rate</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-1e-3</value></param>
<param><key>ymax</key><value>1e-3</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>gui_hint</key><value>2,0,3,2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>ymin</key><value>-1e-3</value></param>
<param><key>ymax</key><value>1e-3</value></param>
<param><key>xmin</key><value>-1e-3</value></param>
<param><key>xmax</key><value>1e-3</value></param>
<param><key>gui_hint</key><value>0,1,2,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>value</key><value>50.0/100.0</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate*rate_multiplier</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>samp_rate</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>gui_hint</key><value>0,0,2,1</value></param>
</block>
<connection><source_block_id>E4406A_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
